# This recipe is example of custom kernel configurations.

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
